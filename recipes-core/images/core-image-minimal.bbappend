WKS_FILE = "sdimage-goldi.wks"
